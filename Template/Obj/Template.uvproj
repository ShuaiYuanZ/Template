# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Lib\inc;..\Lib\src;..\StartUp;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group StartUp
    ../StartUp/: startup_stm32f10x_hd.s
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Lib
    ../Lib/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_usart.c
